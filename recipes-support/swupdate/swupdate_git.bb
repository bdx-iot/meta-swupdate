require swupdate.inc
require swupdate_tools.inc

DEFAULT_PREFERENCE = "-1"

SRCREV ?= "045a618a725d0a2fce64161f10101c0004ac5d85"
